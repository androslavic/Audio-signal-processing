# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\;Lib\CMSIS\Include;Lib\CMSIS\Device\ST\STM32F4xx\Include;Lib\STM32F4xx_StdPeriph_Driver\inc;.\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ./Lib/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./src/: i2c.c i2s.c main.c usart.c timer.c tm_stm32f4_gpio.c tm_stm32f4_mco_output.c
    ./inc/: i2c.h i2s.h main.h stm32f4xx_conf.h usart.h timer.h attributes.h defines.h tm_stm32f4_gpio.h tm_stm32f4_mco_output.h
  group STM_Lib
    ./: STM_Peripheral_Lib_v1.7.1.lib
software components: CMSIS:CORE 4.3.0
